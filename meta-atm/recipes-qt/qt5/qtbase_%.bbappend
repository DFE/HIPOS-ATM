# Append qtbase configuration

PACKAGECONFIG_append_mx6 = " tslib icu sql-sqlite "

QT_CONFIG_FLAGS_append = " -accessibility "
